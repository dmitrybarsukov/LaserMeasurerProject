# Keil uVision project LaserMeasurer.uvprojx, settings and files
target LaserMeasurer (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F030C6Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LaserMeasurer +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F030x6,USE_FULL_LL_DRIVER
  c include: ../Inc;                                                    ../Drivers/STM32F0xx_HAL_Driver/Inc;                                                    ../Drivers/CMSIS/Device/ST/STM32F0xx/Include;                                                    ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Application/MDK-ARM
    ./: startup_stm32f030x6.s
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Application/User
    ../Src/: stm32f0xx_it.c main.c uart_debug.c platform.c
    ../Inc/: platform.h
  group Delay
    ../Src/: delay.c
    ../Inc/: delay.h
  group I2C
    ../Inc/: softi2c.h i2cmemdriver.h si5351drv.h
    ../Src/: softi2c.c i2cmemdriver.c si5351drv.c
  group mathLib
    ../Src/: fastmath.c
    ../Inc/: fastmath.h
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_ll_usart.c stm32f0xx_ll_gpio.c stm32f0xx_ll_exti.c stm32f0xx_ll_dma.c stm32f0xx_ll_rcc.c stm32f0xx_ll_adc.c stm32f0xx_ll_utils.c stm32f0xx_ll_tim.c stm32f0xx_ll_pwr.c
software components: CMSIS:CORE 5.1.1
